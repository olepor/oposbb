
OPOS_SOURCE_DIR="~/CodeFoo/OPOS"